# IAR project YH-RT1052.ewp, settings and files
configuration itcm_txt_ram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\libraries; ..\..\libraries\CMSIS\Include; ..\..\libraries\drivers; ..\..\libraries\utilities; ..\..\libraries\utilities\str; ..\..\libraries\utilities\log; ..\..\libraries\utilities\io; ..\..\libraries\xip; ..\..\user; ..\..\user\bsp; ..\..\user\coremark; ..\..\user\coremark\port
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: YH-RT1052.srec
  ILINK.IlinkOutputFile: YH-RT1052.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration itcm_txt_sdram_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCIncludePath2: ..\..\libraries; ..\..\libraries\CMSIS\Include; ..\..\libraries\drivers; ..\..\libraries\utilities; ..\..\libraries\utilities\str; ..\..\libraries\utilities\log; ..\..\libraries\utilities\io; ..\..\libraries\xip; ..\..\user; ..\..\user\bsp
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_itcm_txt_sdram.icf
configuration sdram_txt_ram_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram_txt_ram.icf
configuration nor_txt_ram (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_ram.icf
configuration nor_txt_sdram (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_txt_sdram.icf
configuration nor_itcm_txt_ram (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; USE_RAM_VECTOR_TABLE
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_itcm_txt_ram .icf
configuration nor_sdram_txt_sdram (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_nor_sdram_txt_sdram.icf
  group board
    ../../user/: board.c clock_config.c pin_mux.c
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    ../../doc/: 必读说明.txt
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_iomuxc.h fsl_lpuart.c
  group startup
    ./: startup_MIMXRT1052.s startup_MIMXRT1052_ram_vector.s
  group user
    ../../user/bsp/systick/: bsp_systick.c
    ../../user/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ../../user/coremark/port/: core_portme.c
    ../../user/: main.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_sbrk.c fsl_shell.c
    ../../libraries/utilities/io/: fsl_io.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/str/: fsl_str.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
